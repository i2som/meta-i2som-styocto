SUMMARY = "i2SOM example of image based on Python3-pyqt5 framework."

require i2som-image-qt.bb

CORE_IMAGE_EXTRA_INSTALL += " \
    python3-pyqt5 \
    "

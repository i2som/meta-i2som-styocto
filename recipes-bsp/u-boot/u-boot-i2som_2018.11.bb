require u-boot-i2som-common_${PV}.inc
require u-boot-i2som.inc

SUMMARY = "Universal Boot Loader for embedded devices for stm32mp"
LICENSE = "GPLv2+"

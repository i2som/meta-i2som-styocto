PACKAGE_INSTALL_append = " i2bootchoose-gui \
	datetime-setting \
    i2launcher \
    i2launcheragent \
    openglcube \
    qtdemo \
    lcd-backlight \
    led-switch \
    doodleboard \
    openglcube \
"

RDEPENDS_packagegroup-framework-tools-kernel-base_append = " nfs-utils "

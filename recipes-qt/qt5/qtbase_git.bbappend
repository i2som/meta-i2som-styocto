PACKAGECONFIG_append = " tslib dbus "
